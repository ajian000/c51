# Keil uVision project c51Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: c51Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\c51project;E:\keil5\C51\INC;E:\keil5\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 main.c
